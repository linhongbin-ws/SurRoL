Commit message: add not on_plane case

File: surrol/assets/tray/tray_pad2.urdf (robot description, URDF)
Before this commit: robot tray, 6 links, 5 joints
Links:
- link baseLink: geometry collision box size=0 0 0; visual mesh filename=meshes/tray.obj scale=1 1 1
